# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ STC
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c OLED.c OLED.h OLED_Font.h UART.c UART.h ADC.c ADC.h PWM.c PWM.h mcu_compat.h
